## boards/shields/test4/Kconfig.defconfig
```kconfig
if SHIELD_TEST4

config ZMK_KEYBOARD_NAME
    default "test4"

endif # SHIELD_TEST4
```
